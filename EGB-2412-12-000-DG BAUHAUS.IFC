Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-2412-12-000-DG BAUHAUS.IFC
Time: 2024-11-05T12:00:41+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 33.0785570092137320; Volume Measure: 0.0330785570092137; Area Measure: 11.8258601380719952

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 33.0785570092137320; Volume Measure: 0.0330785570092137; Area Measure: 11.8258601380719952

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 33.0785570092137320; Volume Measure: 0.0330785570092137; Area Measure: 11.8258601380719952

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-2412-12-000-DG BAUHAUS | PSet_Mass_Property - Mass Measure: 33.0785570092137320; Volume Measure: 0.0330785570092137; Area Measure: 11.8258601380719952
EGB-2412-12-000-DG BAUHAUS | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
