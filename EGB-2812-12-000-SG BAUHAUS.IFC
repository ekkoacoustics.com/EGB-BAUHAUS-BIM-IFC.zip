Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-2812-12-000-SG BAUHAUS.IFC
Time: 2024-11-05T12:01:53+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 40.0426390621926842; Volume Measure: 0.0400426390621927; Area Measure: 13.6716275608010367

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 40.0426390621926842; Volume Measure: 0.0400426390621927; Area Measure: 13.6716275608010367

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 40.0426390621926842; Volume Measure: 0.0400426390621927; Area Measure: 13.6716275608010367

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-2812-12-000-SG BAUHAUS | PSet_Mass_Property - Mass Measure: 40.0426390621926842; Volume Measure: 0.0400426390621927; Area Measure: 13.6716275608010367
EGB-2812-12-000-SG BAUHAUS | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-2812-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
