Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-66-9-000-SG Bauhaus.IFC
Time: 2024-11-05T11:59:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 12.6383816321518747; Volume Measure: 0.0126383816321519; Area Measure: 5.9054484243862939

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 12.6383816321518747; Volume Measure: 0.0126383816321519; Area Measure: 5.9054484243862939

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 12.6383816321518747; Volume Measure: 0.0126383816321519; Area Measure: 5.9054484243862939

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-66-9-000-SG Bauhaus | PSet_Mass_Property - Mass Measure: 12.6383816321518747; Volume Measure: 0.0126383816321519; Area Measure: 5.9054484243862939
EGB-66-9-000-SG Bauhaus | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-66-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
