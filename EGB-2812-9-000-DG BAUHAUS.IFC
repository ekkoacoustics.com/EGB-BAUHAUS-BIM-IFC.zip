Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-2812-9-000-DG BAUHAUS.IFC
Time: 2024-11-05T12:01:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 28.5255867584575853; Volume Measure: 0.0285255867584576; Area Measure: 13.7581035321299119

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 28.5255867584575853; Volume Measure: 0.0285255867584576; Area Measure: 13.7581035321299119

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 28.5255867584575853; Volume Measure: 0.0285255867584576; Area Measure: 13.7581035321299119

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-2812-9-000-DG BAUHAUS | PSet_Mass_Property - Mass Measure: 28.5255867584575853; Volume Measure: 0.0285255867584576; Area Measure: 13.7581035321299119
EGB-2812-9-000-DG BAUHAUS | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-2812-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
