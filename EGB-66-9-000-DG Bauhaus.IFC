Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-66-9-000-DG Bauhaus.IFC
Time: 2024-11-05T11:58:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 12.3354069272220652; Volume Measure: 0.0123354069272221; Area Measure: 5.9836115559614926

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 12.3354069272220652; Volume Measure: 0.0123354069272221; Area Measure: 5.9836115559614926

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 12.3354069272220652; Volume Measure: 0.0123354069272221; Area Measure: 5.9836115559614926

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-66-9-000-DG Bauhaus | PSet_Mass_Property - Mass Measure: 12.3354069272220652; Volume Measure: 0.0123354069272221; Area Measure: 5.9836115559614926
EGB-66-9-000-DG Bauhaus | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-66-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
