Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-66-12-000-SG Bauhaus.IFC
Time: 2024-11-05T11:59:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 16.9583815587538460; Volume Measure: 0.0169583815587539; Area Measure: 5.9342484241416340

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 16.9583815587538460; Volume Measure: 0.0169583815587539; Area Measure: 5.9342484241416340

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 16.9583815587538460; Volume Measure: 0.0169583815587539; Area Measure: 5.9342484241416340

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-66-12-000-SG Bauhaus | PSet_Mass_Property - Mass Measure: 16.9583815587538460; Volume Measure: 0.0169583815587539; Area Measure: 5.9342484241416340
EGB-66-12-000-SG Bauhaus | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-66-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
