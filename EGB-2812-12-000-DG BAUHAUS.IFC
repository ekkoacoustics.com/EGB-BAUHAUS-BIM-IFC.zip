Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-2812-12-000-DG BAUHAUS.IFC
Time: 2024-11-05T12:01:40+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 38.6055867584492276; Volume Measure: 0.0386055867584492; Area Measure: 13.7821035321299057

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 38.6055867584492276; Volume Measure: 0.0386055867584492; Area Measure: 13.7821035321299057

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 38.6055867584492276; Volume Measure: 0.0386055867584492; Area Measure: 13.7821035321299057

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-2812-12-000-DG BAUHAUS | PSet_Mass_Property - Mass Measure: 38.6055867584492276; Volume Measure: 0.0386055867584492; Area Measure: 13.7821035321299057
EGB-2812-12-000-DG BAUHAUS | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-2812-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
