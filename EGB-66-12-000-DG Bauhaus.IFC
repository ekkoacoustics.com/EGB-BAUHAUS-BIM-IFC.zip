Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-66-12-000-DG Bauhaus.IFC
Time: 2024-11-05T11:59:28+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 15.5754068538239991; Volume Measure: 0.0155754068538240; Area Measure: 6.0052115557168317

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 15.5754068538239991; Volume Measure: 0.0155754068538240; Area Measure: 6.0052115557168317

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 15.5754068538239991; Volume Measure: 0.0155754068538240; Area Measure: 6.0052115557168317

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-66-12-000-DG Bauhaus | PSet_Mass_Property - Mass Measure: 15.5754068538239991; Volume Measure: 0.0155754068538240; Area Measure: 6.0052115557168317
EGB-66-12-000-DG Bauhaus | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-66-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
