Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-2412-12-000-SG BAUHAUS.IFC
Time: 2024-11-05T12:00:57+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 34.3257178712338131; Volume Measure: 0.0343257178712338; Area Measure: 11.7303124297769621

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 34.3257178712338131; Volume Measure: 0.0343257178712338; Area Measure: 11.7303124297769621

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 34.3257178712338131; Volume Measure: 0.0343257178712338; Area Measure: 11.7303124297769621

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-2412-12-000-SG BAUHAUS | PSet_Mass_Property - Mass Measure: 34.3257178712338131; Volume Measure: 0.0343257178712338; Area Measure: 11.7303124297769621
EGB-2412-12-000-SG BAUHAUS | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-2412-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
