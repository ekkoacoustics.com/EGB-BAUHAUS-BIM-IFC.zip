Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Bauhaus\EGB-2412-9-000-DG BAUHAUS.IFC
Time: 2024-11-05T12:00:11+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 24.4385570092208617; Volume Measure: 0.0244385570092209; Area Measure: 11.8042601380720011

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 24.4385570092208617; Volume Measure: 0.0244385570092209; Area Measure: 11.8042601380720011

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 24.4385570092208617; Volume Measure: 0.0244385570092209; Area Measure: 11.8042601380720011

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGB-2412-9-000-DG BAUHAUS | PSet_Mass_Property - Mass Measure: 24.4385570092208617; Volume Measure: 0.0244385570092209; Area Measure: 11.8042601380720011
EGB-2412-9-000-DG BAUHAUS | SOLIDWORKS Custom Properties - Description: BAUHAUS; PartNo: EGB-2412-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
